# Keil uVision project FreeRTOS_SharedResource.uvproj, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: LPC2129/01 NXP
  cpu: IRAM(0x40000000-0x40003FFF) IROM(0-0x3FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: FreeRTOS_SharedResource +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\FreeRTOS_Source\include;.\FreeRTOS_Source\portable\RVDS\ARM7_LPC21xx;.\header;.\lib;.
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x40000000 size 0x4000
  group Source Group 1
    ./: FreeRTOSConfig.h Startup.s
    ./source/: GPIO.c GPIO_cfg.c main.c serial.c
    ./header/: serialISR.s
  group FreeRTOS
    ./FreeRTOS_Source/: list.c queue.c tasks.c
    ./FreeRTOS_Source/portable/MemMang/: heap_2.c
    ./FreeRTOS_Source/portable/RVDS/ARM7_LPC21xx/: port.c portASM.s
